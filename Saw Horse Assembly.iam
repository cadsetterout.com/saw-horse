# Autodesk Inventor assembly: Saw Horse Assembly
## iProperties
Created: 2010-08
Part Number: Saw Horse Assembly
Document SubType Name: Assembly
Designer: Paul Munford
Author: Paul Munford
